# Keil uVision project YT32B1_STM32F103_demo.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: YT32B1_STM32F103_demo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\User;.\Startup;.\Hardware\RC522;.\Hardware\OLED;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\Hardware\SW420;.\Hardware\DYSV5W;.\Hardware\MPU6050;.\Hardware\TIME
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_spi.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Hardware
    ./Hardware/RC522/: rc522.c
    ./Hardware/OLED/: oled.c
    ./Hardware/SW420/: sw420.c
    ./Hardware/DYSV5W/: dysv5w.c
    ./Hardware/MPU6050/: IIC.c inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c
    ./Hardware/TIME/: TIME.c
  group sysytem
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
software components: CMSIS:CORE 5.4.0
